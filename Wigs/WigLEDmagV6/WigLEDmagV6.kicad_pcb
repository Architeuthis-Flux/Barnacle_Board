# Repository Architeuthis-Flux/Barnacle_Board

File README.md:

# Barnacle Board Rev 2

Rev 2 is gonna be quite a bit different from the original (from here on, I will refer to this as just **Barnacle Board**), LEDs are a separate board, and there are holes that go all the way through the breadboard (a cool side effect of having spring clips with holes for 5 LEDs), and the connector pinout is changed so you can plug stuff in the wrong way and it just swaps the top and bottom halves of the breadboard.

The idea here is to make an *a la carte* Jumperless, where you can both use this as a luxurious regular breadboard, or plug in a cople Barnacles and turn it into a full-on Jumperless. And you can stack them side-by-side to create the long-awaited full sized Jumperless. 

Or use the card edge connector to plug in other stuff, like solderable protoboards or SMD breakouts and have them mapped 1:1 with the breadboard.

Right now I'm just dumping stuff here. But these will be launching soon in my [store](https://shop.jumperless.org/)

# Barnacle Board
###### an RGB'd out breadboard you can stick things to

The Barnacle Board is a half-size breadboard with RGB LEDs under each row and a 70-pin card edge connector at the top.

This repo will contain all the various Barnacles I come up with. Feel free to submit a PR to add your own!

You can plug in (or stack multiple) Barnacles to do add new functionality to you breadboarding experience without cluttering the part your're working on.

The next few I'm working on are (in a vague chronological order):
 - Proto Barnacle - a cheap solderable protoboard that maps 1:1 to the breadboard ([done, shown here](https://kicanvas.org/?github=https://github.com/Architeuthis-Flux/Barnacle_Board/blob/main/ProtoBarnacle/ProtoBarnacle.kicad_pcb))
 - Sense Barnacle - a thing to continuously measure the voltage on every row and display it as a color/brightness on that row and on the built in OLED ([rough draft of the schematic is here](https://kicanvas.org/?github=https://github.com/Architeuthis-Flux/Barnacle_Board/blob/main/SenseBarnacle/SenseBarnacle.kicad_sch))
 - Dumb Barnacle - a very simple LED driver where row colors can be manually selected, and also a simple, selectable breadboard power supply
 - Internacle - a passive routing hub for multiple barnacles to pass connections between boards
 - SMD Barnacle - a bunch of SMD footprints, similar to the top part of a [Jumperlux](https://github.com/Architeuthis-Flux/JumperLUX) (this project is basically Jumperlux Rev 2 with a new name)
 - Professor Barnacle - wirelessly control the LEDs on any number (or subset of) of boards to help guide students through electronics labs
 - Nixie Barnacle - a nixie tube power supply and footprints for various nixie tube sockets
 - Jumperless Barnacle - a [Jumperless](https://github.com/Architeuthis-Flux/Jumperless) with an edge connector instead of an integrated breadboard

If you think of any new ones that might be useful or if you disagree with the order I've put these in and think one should be prioritized, let me know!

Here's the spec for the edge connector in case you want to make your own Barnacles

## KiCad design Wigs/WigLEDmagV6/WigLEDmagV6.kicad_pcb

Schematic: WigLEDmagV6.kicad_sch

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14: 1uF; C_0402_1005Metric
C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31: 0.1uF; C_0402_1005Metric
D11, D12, D13, D14, D15, D16, D21, D22, D23, D24, D25, D26, D31, D32, D33, D34, D35, D36, D41, D42, D43, D44, D45, D46, D51, D52, D53, D54, D55, D56, D61, D62, D63, D64, D65, D66, D71, D72, D73, D74, D75, D76, D81, D82, D83, D84, D85, D86, D91, D92, D93, D94, D95, D96, D101, D102, D103, D104, D105, D106, D111, D112, D113, D114, D115, D116, D121, D122, D123, D124, D125, D126, D131, D132, D133, D134, D135, D136, D141, D142, D143, D144, D145, D146, D151, D152, D153, D154, D155, D156, D161, D162, D163, D164, D165, D166, D171, D172, D173, D174, D175, D176, D181, D182, D183, D184, D185, D186, D191, D192, D193, D194, D195, D196, D201, D202, D203, D204, D205, D206, D211, D212, D213, D214, D215, D216, D221, D222, D223, D224, D225, D226, D231, D232, D233, D234, D235, D236, D241, D242, D243, D244, D245, D246, D251, D252, D253, D254, D255, D256, D261, D262, D263, D264, D265, D266, D271, D272, D273, D274, D275, D276, D281, D282, D283, D284, D285, D286, D291, D292, D293, D294, D295, D296, D301, D302, D303, D304, D305, D306, D311, D312, D313, D314, D315, D316, D321, D322, D323, D324, D325, D326, D331, D332, D333, D334, D335, D336, D341, D342, D343, D344, D345, D346, D351, D352, D353, D354, D355, D356, D361, D362, D363, D364, D365, D366, D371, D372, D373, D374, D375, D376, D381, D382, D383, D384, D385, D386, D391, D392, D393, D394, D395, D396, D401, D402, D403, D404, D405, D406, D411, D412, D413, D414, D415, D416, D421, D422, D423, D424, D425, D426, D431, D432, D433, D434, D435, D436, D441, D442, D443, D444, D445, D446, D451, D452, D453, D454, D455, D456, D461, D462, D463, D464, D465, D466, D471, D472, D473, D474, D475, D476, D481, D482, D483, D484, D485, D486, D491, D492, D493, D494, D495, D496, D501, D502, D503, D504, D505, D506, D511, D512, D513, D514, D515, D516, D521, D522, D523, D524, D525, D526, D531, D532, D533, D534, D535, D536, D541, D542, D543, D544, D545, D546, D551, D552, D553, D554, D555, D556, D561, D562, D563, D564, D565, D566, D571, D572, D573, D574, D575, D576, D581, D582, D583, D584, D585, D586, D591, D592, D593, D594, D595, D596, D601, D602, D603, D604, D605, D606, D611, D612, D613, D614, D615, D616, D617, D618, D619, D621, D622, D623, D624, D625, D626, D627, D628, D629, D631, D632, D633, D634, D635, D636, D637, D638, D639, D641, D642, D643, D644, D645, D646, D647, D648, D649, D6110, D6111, D6112, D6113, D6114, D6115, D6116, D6117, D6118, D6119, D6120, D6121, D6122, D6123, D6124, D6125, D6126, D6127, D6128, D6129, D6130, D6210, D6211, D6212, D6213, D6214, D6215, D6216, D6217, D6218, D6219, D6220, D6221, D6222, D6223, D6224, D6225, D6226, D6227, D6228, D6229, D6230, D6310, D6311, D6312, D6313, D6314, D6315, D6316, D6317, D6318, D6319, D6320, D6321, D6322, D6323, D6324, D6325, D6326, D6327, D6328, D6329, D6330, D6410, D6411, D6412, D6413, D6414, D6415, D6416, D6417, D6418, D6419, D6420, D6421, D6422, D6423, D6424, D6425, D6426, D6427, D6428, D6429, D6430: WS2812B; XL-1010RGBC-WS2812B; LCSC C5349953
J1: SENSE_60; not fitted
J2, J3: Barnacle_Connector_70pin; not fitted
J4: SENSE_1; not fitted
J5: SENSE_30; not fitted
J6: SENSE_31; not fitted
J7, J9: Conn_01x01; Banana_Plus; not fitted
J8, J10: Conn_01x01; Banana_Minus; not fitted
J11: not fitted
J12, J13: Conn_01x32; fulledge_gap; not fitted
J14, J15, J16: Conn_01x01; Conn_1x1; not fitted
JP1, JP2: Jumper_2_Open; SolderJumper_2_Open_Small; not fitted
JP3, JP4, JP5: M~{INT}; SolderJumper_2_Bridged_Small; not fitted
M51, M52, M53, M54, M55, M56, M57, M58, M59: SOT-23-6_TMAG5273
R1, R2: 4.7K; R_0603_1608Metric
TP1, TP2: GND; TestPoint_Pad_D1.0mm; not fitted
TP3: LED OUT; PINHEADER-1x1_vertical; not fitted
TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP26, TP27, TP28, TP29: TestPoint; TestPoint_Pad_D1.0mm; not fitted
U1: TCA9548APWR; TSSOP-24_4.4x7.8mm_P0.65mm
U2, U4, U5, U6, U7, U8, U9, U10: MMC5603NJL; WLP-4_0.86x0.86mm_P0.4mm
U3: AP2127N-3.3; SOT-23
U11, U12: Maxim_WLP-12_2.008x1.608mm_Layout4x3_P0.4mm; not fitted

Connections:
+3.3V: C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, J12.16, J13.16, R1.1, R2.1, TP11.1 (1_1), TP25.1, U1.24 (VCC), U2.B1 (VDD), U3.2 (VO), U4.B1 (VDD), U5.B1 (VDD), U6.B1 (VDD), U7.B1 (VDD), U8.B1 (VDD), U9.B1 (VDD), U10.B1 (VDD)
A0: J12.19, TP7.1 (1_1), U1.1 (A0)
A1: J12.20, TP6.1 (1_1), U1.2 (A1)
A2: J12.21, TP5.1 (1_1), U1.21 (A2)
BOT_NEG: J2.64 (B-), J3.64 (B-), J10.1 (Pin_1_1), J11.64 (Bot_Neg), J13.3, JP1.2 (B), U12.A4 (S2)
BOT_POS: J2.63 (B+), J3.63 (B+), J9.1 (Pin_1_1), J11.63 (Bot_Pos), J13.2, JP2.1 (A), U12.A3 (S1)
IN1_1: J12.11, U11.B4 (IN2)
IN1_30: J13.11, U12.B3 (IN1)
IN2_1: J12.12, U11.B3 (IN1)
IN2_30: J13.12, U12.B4 (IN2)
LED_5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, D11.2 (VDD), D12.2 (VDD), D13.2 (VDD), D14.2 (VDD), D15.2 (VDD), D16.2 (VDD), D21.2 (VDD), D22.2 (VDD), D23.2 (VDD), D24.2 (VDD), D25.2 (VDD), D26.2 (VDD), D31.2 (VDD), D32.2 (VDD), D33.2 (VDD), D34.2 (VDD), D35.2 (VDD), D36.2 (VDD), D41.2 (VDD), D42.2 (VDD), D43.2 (VDD), D44.2 (VDD), D45.2 (VDD), D46.2 (VDD), D51.2 (VDD), D52.2 (VDD), D53.2 (VDD), D54.2 (VDD), D55.2 (VDD), D56.2 (VDD), D61.2 (VDD), D62.2 (VDD), D63.2 (VDD), D64.2 (VDD), D65.2 (VDD), D66.2 (VDD), D71.2 (VDD), D72.2 (VDD), D73.2 (VDD), D74.2 (VDD), D75.2 (VDD), D76.2 (VDD), D81.2 (VDD), D82.2 (VDD), D83.2 (VDD), D84.2 (VDD), D85.2 (VDD), D86.2 (VDD), D91.2 (VDD), D92.2 (VDD), D93.2 (VDD), D94.2 (VDD), D95.2 (VDD), D96.2 (VDD), D101.2 (VDD), D102.2 (VDD), D103.2 (VDD), D104.2 (VDD), D105.2 (VDD), D106.2 (VDD), D111.2 (VDD), D112.2 (VDD), D113.2 (VDD), D114.2 (VDD), D115.2 (VDD), D116.2 (VDD)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
LED_60_OUT: D606.1 (DOUT), D611.4 (DIN), J13.13, TP23.1 (1_1)
LED_DATA_BBin: D11.4 (DIN), J2.68 (LED_DATA_BBin), J3.68 (LED_DATA_BBin), J12.5, J12.13, J14.1 (Pin_1_1), TP24.1 (1_1)
LED_DATA_BBout: D6430.1 (DOUT), J2.65 (LED_DATA_BBout), J3.65 (LED_DATA_BBout), TP3.1 (1_1)
LED_GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, D11.3 (VSS), D12.3 (VSS), D13.3 (VSS), D14.3 (VSS), D15.3 (VSS), D16.3 (VSS), D21.3 (VSS), D22.3 (VSS), D23.3 (VSS), D24.3 (VSS), D25.3 (VSS), D26.3 (VSS), D31.3 (VSS), D32.3 (VSS), D33.3 (VSS), D34.3 (VSS), D35.3 (VSS), D36.3 (VSS), D41.3 (VSS), D42.3 (VSS), D43.3 (VSS), D44.3 (VSS), D45.3 (VSS), D46.3 (VSS), D51.3 (VSS), D52.3 (VSS), D53.3 (VSS), D54.3 (VSS), D55.3 (VSS), D56.3 (VSS), D61.3 (VSS), D62.3 (VSS), D63.3 (VSS), D64.3 (VSS), D65.3 (VSS), D66.3 (VSS), D71.3 (VSS), D72.3 (VSS), D73.3 (VSS), D74.3 (VSS), D75.3 (VSS), D76.3 (VSS), D81.3 (VSS), D82.3 (VSS), D83.3 (VSS), D84.3 (VSS), D85.3 (VSS), D86.3 (VSS), D91.3 (VSS), D92.3 (VSS), D93.3 (VSS), D94.3 (VSS), D95.3 (VSS), D96.3 (VSS), D101.3 (VSS), D102.3 (VSS), D103.3 (VSS), D104.3 (VSS)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
MGND_0: C15.2, C16.2, C17.2, J13.20, M52.2 (GND), M52.3 (GND^{TEST}), M54.2 (GND), M54.3 (GND^{TEST}), M56.2 (GND), M56.3 (GND^{TEST}), TP20.1 (1_1)
MGND_1: C18.2, C19.2, C20.2, J13.21, M51.2 (GND), M51.3 (GND^{TEST}), M53.2 (GND), M53.3 (GND^{TEST}), M58.2 (GND), M58.3 (GND^{TEST}), TP21.1 (1_1)
MGND_2: C21.2, C22.2, C23.2, J13.22, M55.2 (GND), M55.3 (GND^{TEST}), M57.2 (GND), M57.3 (GND^{TEST}), M59.2 (GND), M59.3 (GND^{TEST}), TP22.1 (1_1)
MVCC_0: C15.1, C18.1, C21.1, J12.30, J13.4, M52.4 (Vcc), M55.4 (Vcc), M58.4 (Vcc), TP17.1 (1_1)
MVCC_1: C16.1, C19.1, C22.1, J12.31, J13.5, M51.4 (Vcc), M54.4 (Vcc), M57.4 (Vcc), TP18.1 (1_1)
MVCC_2: C17.1, C20.1, C23.1, J12.32, J13.6, M53.4 (Vcc), M56.4 (Vcc), M59.4 (Vcc), TP19.1 (1_1); also elsewhere on the board
M~INT: J13.19, JP3.2 (B), JP4.2 (B), JP5.2 (B), TP16.1 (1_1)
M~INT_0: JP3.1 (A), M52.5 (~INT), M55.5 (~INT), M58.5 (~INT), TP27.1 (1_1)
M~INT_1: JP4.1 (A), M51.5 (~INT), M54.5 (~INT), M57.5 (~INT), TP28.1 (1_1)
M~INT_2: JP5.1 (A), M53.5 (~INT), M56.5 (~INT), M59.5 (~INT), TP29.1 (1_1)
unnamed: D11.1 (DOUT), D12.4 (DIN)
unnamed: D12.1 (DOUT), D13.4 (DIN)
unnamed: D13.1 (DOUT), D14.4 (DIN)
unnamed: D14.1 (DOUT), D15.4 (DIN)
unnamed: D15.1 (DOUT), D16.4 (DIN)
unnamed: D16.1 (DOUT), D21.4 (DIN)
unnamed: D21.1 (DOUT), D22.4 (DIN)
unnamed: D22.1 (DOUT), D23.4 (DIN)
unnamed: D23.1 (DOUT), D24.4 (DIN)
unnamed: D24.1 (DOUT), D25.4 (DIN)
unnamed: D25.1 (DOUT), D26.4 (DIN)
unnamed: D26.1 (DOUT), D31.4 (DIN)
unnamed: D31.1 (DOUT), D32.4 (DIN)
unnamed: D32.1 (DOUT), D33.4 (DIN)
unnamed: D33.1 (DOUT), D34.4 (DIN)
unnamed: D34.1 (DOUT), D35.4 (DIN)
unnamed: D35.1 (DOUT), D36.4 (DIN)
unnamed: D36.1 (DOUT), D41.4 (DIN)
unnamed: D41.1 (DOUT), D42.4 (DIN)
unnamed: D42.1 (DOUT), D43.4 (DIN)
unnamed: D43.1 (DOUT), D44.4 (DIN)
unnamed: D44.1 (DOUT), D45.4 (DIN)
unnamed: D45.1 (DOUT), D46.4 (DIN)
unnamed: D46.1 (DOUT), D51.4 (DIN)
unnamed: D51.1 (DOUT), D52.4 (DIN)
unnamed: D52.1 (DOUT), D53.4 (DIN)
unnamed: D53.1 (DOUT), D54.4 (DIN)
unnamed: D54.1 (DOUT), D55.4 (DIN)
unnamed: D55.1 (DOUT), D56.4 (DIN)
unnamed: D56.1 (DOUT), D61.4 (DIN)
unnamed: D61.1 (DOUT), D62.4 (DIN)
unnamed: D62.1 (DOUT), D63.4 (DIN)
unnamed: D63.1 (DOUT), D64.4 (DIN)
unnamed: D64.1 (DOUT), D65.4 (DIN)
unnamed: D65.1 (DOUT), D66.4 (DIN)
unnamed: D66.1 (DOUT), D71.4 (DIN)
unnamed: D71.1 (DOUT), D72.4 (DIN)
unnamed: D72.1 (DOUT), D73.4 (DIN)
unnamed: D73.1 (DOUT), D74.4 (DIN)
unnamed: D74.1 (DOUT), D75.4 (DIN)
unnamed: D75.1 (DOUT), D76.4 (DIN)
unnamed: D76.1 (DOUT), D81.4 (DIN)
unnamed: D81.1 (DOUT), D82.4 (DIN)
unnamed: D82.1 (DOUT), D83.4 (DIN)
unnamed: D83.1 (DOUT), D84.4 (DIN)
unnamed: D84.1 (DOUT), D85.4 (DIN)
unnamed: D85.1 (DOUT), D86.4 (DIN)
unnamed: D86.1 (DOUT), D91.4 (DIN)
unnamed: D91.1 (DOUT), D92.4 (DIN)
unnamed: D92.1 (DOUT), D93.4 (DIN)
unnamed: D93.1 (DOUT), D94.4 (DIN)
unnamed: D94.1 (DOUT), D95.4 (DIN)
unnamed: D95.1 (DOUT), D96.4 (DIN)
unnamed: D96.1 (DOUT), D101.4 (DIN)
unnamed: D101.1 (DOUT), D102.4 (DIN)
unnamed: D102.1 (DOUT), D103.4 (DIN)
unnamed: D103.1 (DOUT), D104.4 (DIN)
unnamed: D104.1 (DOUT), D105.4 (DIN)
unnamed: D105.1 (DOUT), D106.4 (DIN)
unnamed: D106.1 (DOUT), D111.4 (DIN)
unnamed: D111.1 (DOUT), D112.4 (DIN)
unnamed: D112.1 (DOUT), D113.4 (DIN)
unnamed: D113.1 (DOUT), D114.4 (DIN)
unnamed: D114.1 (DOUT), D115.4 (DIN)
unnamed: D115.1 (DOUT), D116.4 (DIN)
unnamed: D116.1 (DOUT), D121.4 (DIN)
unnamed: D121.1 (DOUT), D122.4 (DIN)
unnamed: D122.1 (DOUT), D123.4 (DIN)
unnamed: D123.1 (DOUT), D124.4 (DIN)
unnamed: D124.1 (DOUT), D125.4 (DIN)
unnamed: D125.1 (DOUT), D126.4 (DIN)
unnamed: D126.1 (DOUT), D131.4 (DIN)
unnamed: D131.1 (DOUT), D132.4 (DIN)
unnamed: D132.1 (DOUT), D133.4 (DIN)
unnamed: D133.1 (DOUT), D134.4 (DIN)
unnamed: D134.1 (DOUT), D135.4 (DIN)
unnamed: D135.1 (DOUT), D136.4 (DIN)
unnamed: D136.1 (DOUT), D141.4 (DIN)
unnamed: D141.1 (DOUT), D142.4 (DIN)
unnamed: D142.1 (DOUT), D143.4 (DIN)
unnamed: D143.1 (DOUT), D144.4 (DIN)
unnamed: D144.1 (DOUT), D145.4 (DIN)
unnamed: D145.1 (DOUT), D146.4 (DIN)
unnamed: D146.1 (DOUT), D151.4 (DIN)
unnamed: D151.1 (DOUT), D152.4 (DIN)
unnamed: D152.1 (DOUT), D153.4 (DIN)
unnamed: D153.1 (DOUT), D154.4 (DIN)
unnamed: D154.1 (DOUT), D155.4 (DIN)
unnamed: D155.1 (DOUT), D156.4 (DIN)
unnamed: D156.1 (DOUT), D161.4 (DIN)
unnamed: D161.1 (DOUT), D162.4 (DIN)
unnamed: D162.1 (DOUT), D163.4 (DIN)
unnamed: D163.1 (DOUT), D164.4 (DIN)
unnamed: D164.1 (DOUT), D165.4 (DIN)
unnamed: D165.1 (DOUT), D166.4 (DIN)
unnamed: D166.1 (DOUT), D171.4 (DIN)
unnamed: D171.1 (DOUT), D172.4 (DIN)
unnamed: D172.1 (DOUT), D173.4 (DIN)
unnamed: D173.1 (DOUT), D174.4 (DIN)
unnamed: D174.1 (DOUT), D175.4 (DIN)
unnamed: D175.1 (DOUT), D176.4 (DIN)
unnamed: D176.1 (DOUT), D181.4 (DIN)
unnamed: D181.1 (DOUT), D182.4 (DIN)
unnamed: D182.1 (DOUT), D183.4 (DIN)
unnamed: D183.1 (DOUT), D184.4 (DIN)
unnamed: D184.1 (DOUT), D185.4 (DIN)
unnamed: D185.1 (DOUT), D186.4 (DIN)
unnamed: D186.1 (DOUT), D191.4 (DIN)
unnamed: D191.1 (DOUT), D192.4 (DIN)
unnamed: D192.1 (DOUT), D193.4 (DIN)
unnamed: D193.1 (DOUT), D194.4 (DIN)
unnamed: D194.1 (DOUT), D195.4 (DIN)
unnamed: D195.1 (DOUT), D196.4 (DIN)
unnamed: D196.1 (DOUT), D201.4 (DIN)
unnamed: D201.1 (DOUT), D202.4 (DIN)
unnamed: D202.1 (DOUT), D203.4 (DIN)
unnamed: D203.1 (DOUT), D204.4 (DIN)
unnamed: D204.1 (DOUT), D205.4 (DIN)
unnamed: D205.1 (DOUT), D206.4 (DIN)
unnamed: D206.1 (DOUT), D211.4 (DIN)
unnamed: D211.1 (DOUT), D212.4 (DIN)
unnamed: D212.1 (DOUT), D213.4 (DIN)
unnamed: D213.1 (DOUT), D214.4 (DIN)
unnamed: D214.1 (DOUT), D215.4 (DIN)
unnamed: D215.1 (DOUT), D216.4 (DIN)
unnamed: D216.1 (DOUT), D221.4 (DIN)
unnamed: D221.1 (DOUT), D222.4 (DIN)
unnamed: D222.1 (DOUT), D223.4 (DIN)
unnamed: D223.1 (DOUT), D224.4 (DIN)
unnamed: D224.1 (DOUT), D225.4 (DIN)
unnamed: D225.1 (DOUT), D226.4 (DIN)
unnamed: D226.1 (DOUT), D231.4 (DIN)
unnamed: D231.1 (DOUT), D232.4 (DIN)
unnamed: D232.1 (DOUT), D233.4 (DIN)
unnamed: D233.1 (DOUT), D234.4 (DIN)
unnamed: D234.1 (DOUT), D235.4 (DIN)
unnamed: D235.1 (DOUT), D236.4 (DIN)
unnamed: D236.1 (DOUT), D241.4 (DIN)
unnamed: D241.1 (DOUT), D242.4 (DIN)
unnamed: D242.1 (DOUT), D243.4 (DIN)
unnamed: D243.1 (DOUT), D244.4 (DIN)
unnamed: D244.1 (DOUT), D245.4 (DIN)
unnamed: D245.1 (DOUT), D246.4 (DIN)
unnamed: D246.1 (DOUT), D251.4 (DIN)
unnamed: D251.1 (DOUT), D252.4 (DIN)
unnamed: D252.1 (DOUT), D253.4 (DIN)
unnamed: D253.1 (DOUT), D254.4 (DIN)
unnamed: D254.1 (DOUT), D255.4 (DIN)
unnamed: D255.1 (DOUT), D256.4 (DIN)
unnamed: D256.1 (DOUT), D261.4 (DIN)
unnamed: D261.1 (DOUT), D262.4 (DIN)
unnamed: D262.1 (DOUT), D263.4 (DIN)
unnamed: D263.1 (DOUT), D264.4 (DIN)
unnamed: D264.1 (DOUT), D265.4 (DIN)
unnamed: D265.1 (DOUT), D266.4 (DIN)
unnamed: D266.1 (DOUT), D271.4 (DIN)
unnamed: D271.1 (DOUT), D272.4 (DIN)
unnamed: D272.1 (DOUT), D273.4 (DIN)
unnamed: D273.1 (DOUT), D274.4 (DIN)
unnamed: D274.1 (DOUT), D275.4 (DIN)
unnamed: D275.1 (DOUT), D276.4 (DIN)
unnamed: D276.1 (DOUT), D281.4 (DIN)
unnamed: D281.1 (DOUT), D282.4 (DIN)
unnamed: D282.1 (DOUT), D283.4 (DIN)
unnamed: D283.1 (DOUT), D284.4 (DIN)
unnamed: D284.1 (DOUT), D285.4 (DIN)
unnamed: D285.1 (DOUT), D286.4 (DIN)
unnamed: D286.1 (DOUT), D291.4 (DIN)
unnamed: D291.1 (DOUT), D292.4 (DIN)
unnamed: D292.1 (DOUT), D293.4 (DIN)
unnamed: D293.1 (DOUT), D294.4 (DIN)
unnamed: D294.1 (DOUT), D295.4 (DIN)
unnamed: D295.1 (DOUT), D296.4 (DIN)
unnamed: D296.1 (DOUT), D301.4 (DIN)
unnamed: D301.1 (DOUT), D302.4 (DIN)
unnamed: D302.1 (DOUT), D303.4 (DIN)
unnamed: D303.1 (DOUT), D304.4 (DIN)
unnamed: D304.1 (DOUT), D305.4 (DIN)
unnamed: D305.1 (DOUT), D306.4 (DIN)
unnamed: D306.1 (DOUT), D311.4 (DIN)
unnamed: D311.1 (DOUT), D312.4 (DIN)
unnamed: D312.1 (DOUT), D313.4 (DIN)
unnamed: D313.1 (DOUT), D314.4 (DIN)
unnamed: D314.1 (DOUT), D315.4 (DIN)
unnamed: D315.1 (DOUT), D316.4 (DIN)
unnamed: D316.1 (DOUT), D321.4 (DIN)
unnamed: D321.1 (DOUT), D322.4 (DIN)
unnamed: D322.1 (DOUT), D323.4 (DIN)
unnamed: D323.1 (DOUT), D324.4 (DIN)
unnamed: D324.1 (DOUT), D325.4 (DIN)
unnamed: D325.1 (DOUT), D326.4 (DIN)
unnamed: D326.1 (DOUT), D331.4 (DIN)
unnamed: D331.1 (DOUT), D332.4 (DIN)
unnamed: D332.1 (DOUT), D333.4 (DIN)
unnamed: D333.1 (DOUT), D334.4 (DIN)
unnamed: D334.1 (DOUT), D335.4 (DIN)
unnamed: D335.1 (DOUT), D336.4 (DIN)
unnamed: D336.1 (DOUT), D341.4 (DIN)
unnamed: D341.1 (DOUT), D342.4 (DIN)
unnamed: D342.1 (DOUT), D343.4 (DIN)
unnamed: D343.1 (DOUT), D344.4 (DIN)
unnamed: D344.1 (DOUT), D345.4 (DIN)
unnamed: D345.1 (DOUT), D346.4 (DIN)
unnamed: D346.1 (DOUT), D351.4 (DIN)
unnamed: D351.1 (DOUT), D352.4 (DIN)
unnamed: D352.1 (DOUT), D353.4 (DIN)
unnamed: D353.1 (DOUT), D354.4 (DIN)
unnamed: D354.1 (DOUT), D355.4 (DIN)
unnamed: D355.1 (DOUT), D356.4 (DIN)
unnamed: D356.1 (DOUT), D361.4 (DIN)
unnamed: D361.1 (DOUT), D362.4 (DIN)
unnamed: D362.1 (DOUT), D363.4 (DIN)
unnamed: D363.1 (DOUT), D364.4 (DIN)
unnamed: D364.1 (DOUT), D365.4 (DIN)
unnamed: D365.1 (DOUT), D366.4 (DIN)
unnamed: D366.1 (DOUT), D371.4 (DIN)
unnamed: D371.1 (DOUT), D372.4 (DIN)
unnamed: D372.1 (DOUT), D373.4 (DIN)
unnamed: D373.1 (DOUT), D374.4 (DIN)
unnamed: D374.1 (DOUT), D375.4 (DIN)
unnamed: D375.1 (DOUT), D376.4 (DIN)
unnamed: D376.1 (DOUT), D381.4 (DIN)
unnamed: D381.1 (DOUT), D382.4 (DIN)
unnamed: D382.1 (DOUT), D383.4 (DIN)
unnamed: D383.1 (DOUT), D384.4 (DIN)
unnamed: D384.1 (DOUT), D385.4 (DIN)
unnamed: D385.1 (DOUT), D386.4 (DIN)
unnamed: D386.1 (DOUT), D391.4 (DIN)
unnamed: D391.1 (DOUT), D392.4 (DIN)
unnamed: D392.1 (DOUT), D393.4 (DIN)
unnamed: D393.1 (DOUT), D394.4 (DIN)
unnamed: D394.1 (DOUT), D395.4 (DIN)
unnamed: D395.1 (DOUT), D396.4 (DIN)
unnamed: D396.1 (DOUT), D401.4 (DIN)
unnamed: D401.1 (DOUT), D402.4 (DIN)
unnamed: D402.1 (DOUT), D403.4 (DIN)
unnamed: D403.1 (DOUT), D404.4 (DIN)
unnamed: D404.1 (DOUT), D405.4 (DIN)
unnamed: D405.1 (DOUT), D406.4 (DIN)
unnamed: D406.1 (DOUT), D411.4 (DIN)
unnamed: D411.1 (DOUT), D412.4 (DIN)
unnamed: D412.1 (DOUT), D413.4 (DIN)
unnamed: D413.1 (DOUT), D414.4 (DIN)
unnamed: D414.1 (DOUT), D415.4 (DIN)
unnamed: D415.1 (DOUT), D416.4 (DIN)
unnamed: D416.1 (DOUT), D421.4 (DIN)
unnamed: D421.1 (DOUT), D422.4 (DIN)
unnamed: D422.1 (DOUT), D423.4 (DIN)
unnamed: D423.1 (DOUT), D424.4 (DIN)
unnamed: D424.1 (DOUT), D425.4 (DIN)
unnamed: D425.1 (DOUT), D426.4 (DIN)
unnamed: D426.1 (DOUT), D431.4 (DIN)
unnamed: D431.1 (DOUT), D432.4 (DIN)
unnamed: D432.1 (DOUT), D433.4 (DIN)
unnamed: D433.1 (DOUT), D434.4 (DIN)
unnamed: D434.1 (DOUT), D435.4 (DIN)
unnamed: D435.1 (DOUT), D436.4 (DIN)
unnamed: D436.1 (DOUT), D441.4 (DIN)
unnamed: D441.1 (DOUT), D442.4 (DIN)
unnamed: D442.1 (DOUT), D443.4 (DIN)
unnamed: D443.1 (DOUT), D444.4 (DIN)
unnamed: D444.1 (DOUT), D445.4 (DIN)
unnamed: D445.1 (DOUT), D446.4 (DIN)
unnamed: D446.1 (DOUT), D451.4 (DIN)
unnamed: D451.1 (DOUT), D452.4 (DIN)
unnamed: D452.1 (DOUT), D453.4 (DIN)
unnamed: D453.1 (DOUT), D454.4 (DIN)
unnamed: D454.1 (DOUT), D455.4 (DIN)
unnamed: D455.1 (DOUT), D456.4 (DIN)
unnamed: D456.1 (DOUT), D461.4 (DIN)
unnamed: D461.1 (DOUT), D462.4 (DIN)
unnamed: D462.1 (DOUT), D463.4 (DIN)
unnamed: D463.1 (DOUT), D464.4 (DIN)
unnamed: D464.1 (DOUT), D465.4 (DIN)
unnamed: D465.1 (DOUT), D466.4 (DIN)
unnamed: D466.1 (DOUT), D471.4 (DIN)
unnamed: D471.1 (DOUT), D472.4 (DIN)
unnamed: D472.1 (DOUT), D473.4 (DIN)
unnamed: D473.1 (DOUT), D474.4 (DIN)
unnamed: D474.1 (DOUT), D475.4 (DIN)
unnamed: D475.1 (DOUT), D476.4 (DIN)
unnamed: D476.1 (DOUT), D481.4 (DIN)
unnamed: D481.1 (DOUT), D482.4 (DIN)
unnamed: D482.1 (DOUT), D483.4 (DIN)
unnamed: D483.1 (DOUT), D484.4 (DIN)
unnamed: D484.1 (DOUT), D485.4 (DIN)
unnamed: D485.1 (DOUT), D486.4 (DIN)
unnamed: D486.1 (DOUT), D491.4 (DIN)
unnamed: D491.1 (DOUT), D492.4 (DIN)
unnamed: D492.1 (DOUT), D493.4 (DIN)
unnamed: D493.1 (DOUT), D494.4 (DIN)
unnamed: D494.1 (DOUT), D495.4 (DIN)
unnamed: D495.1 (DOUT), D496.4 (DIN)
unnamed: D496.1 (DOUT), D501.4 (DIN)
unnamed: D501.1 (DOUT), D502.4 (DIN)
unnamed: D502.1 (DOUT), D503.4 (DIN)
unnamed: D503.1 (DOUT), D504.4 (DIN)
unnamed: D504.1 (DOUT), D505.4 (DIN)
unnamed: D505.1 (DOUT), D506.4 (DIN)
unnamed: D506.1 (DOUT), D511.4 (DIN)
unnamed: D511.1 (DOUT), D512.4 (DIN)
unnamed: D512.1 (DOUT), D513.4 (DIN)
unnamed: D513.1 (DOUT), D514.4 (DIN)
unnamed: D514.1 (DOUT), D515.4 (DIN)
unnamed: D515.1 (DOUT), D516.4 (DIN)
unnamed: D516.1 (DOUT), D521.4 (DIN)
unnamed: D521.1 (DOUT), D522.4 (DIN)
unnamed: D522.1 (DOUT), D523.4 (DIN)
unnamed: D523.1 (DOUT), D524.4 (DIN)
unnamed: D524.1 (DOUT), D525.4 (DIN)
unnamed: D525.1 (DOUT), D526.4 (DIN)
unnamed: D526.1 (DOUT), D531.4 (DIN)
unnamed: D531.1 (DOUT), D532.4 (DIN)
unnamed: D532.1 (DOUT), D533.4 (DIN)
unnamed: D533.1 (DOUT), D534.4 (DIN)
unnamed: D534.1 (DOUT), D535.4 (DIN)
unnamed: D535.1 (DOUT), D536.4 (DIN)
unnamed: D536.1 (DOUT), D541.4 (DIN)
unnamed: D541.1 (DOUT), D542.4 (DIN)
unnamed: D542.1 (DOUT), D543.4 (DIN)
unnamed: D543.1 (DOUT), D544.4 (DIN)
unnamed: D544.1 (DOUT), D545.4 (DIN)
unnamed: D545.1 (DOUT), D546.4 (DIN)
unnamed: D546.1 (DOUT), D551.4 (DIN)
unnamed: D551.1 (DOUT), D552.4 (DIN)
unnamed: D552.1 (DOUT), D553.4 (DIN)
unnamed: D553.1 (DOUT), D554.4 (DIN)
unnamed: D554.1 (DOUT), D555.4 (DIN)
unnamed: D555.1 (DOUT), D556.4 (DIN)
unnamed: D556.1 (DOUT), D561.4 (DIN)
unnamed: D561.1 (DOUT), D562.4 (DIN)
unnamed: D562.1 (DOUT), D563.4 (DIN)
unnamed: D563.1 (DOUT), D564.4 (DIN)
unnamed: D564.1 (DOUT), D565.4 (DIN)
unnamed: D565.1 (DOUT), D566.4 (DIN)
unnamed: D566.1 (DOUT), D571.4 (DIN)
unnamed: D571.1 (DOUT), D572.4 (DIN)
unnamed: D572.1 (DOUT), D573.4 (DIN)
unnamed: D573.1 (DOUT), D574.4 (DIN)
unnamed: D574.1 (DOUT), D575.4 (DIN)
unnamed: D575.1 (DOUT), D576.4 (DIN)
unnamed: D576.1 (DOUT), D581.4 (DIN)
unnamed: D581.1 (DOUT), D582.4 (DIN)
unnamed: D582.1 (DOUT), D583.4 (DIN)
unnamed: D583.1 (DOUT), D584.4 (DIN)
unnamed: D584.1 (DOUT), D585.4 (DIN)
unnamed: D585.1 (DOUT), D586.4 (DIN)
unnamed: D586.1 (DOUT), D591.4 (DIN)
unnamed: D591.1 (DOUT), D592.4 (DIN)
unnamed: D592.1 (DOUT), D593.4 (DIN)
unnamed: D593.1 (DOUT), D594.4 (DIN)
unnamed: D594.1 (DOUT), D595.4 (DIN)
unnamed: D595.1 (DOUT), D596.4 (DIN)
unnamed: D596.1 (DOUT), D601.4 (DIN)
unnamed: D601.1 (DOUT), D602.4 (DIN)
unnamed: D602.1 (DOUT), D603.4 (DIN)
unnamed: D603.1 (DOUT), D604.4 (DIN)
unnamed: D604.1 (DOUT), D605.4 (DIN)
unnamed: D605.1 (DOUT), D606.4 (DIN)
unnamed: D611.1 (DOUT), D612.4 (DIN)
unnamed: D612.1 (DOUT), D613.4 (DIN)
unnamed: D613.1 (DOUT), D614.4 (DIN)
unnamed: D614.1 (DOUT), D615.4 (DIN)
unnamed: D615.1 (DOUT), D616.4 (DIN)
unnamed: D616.1 (DOUT), D617.4 (DIN)
unnamed: D617.1 (DOUT), D618.4 (DIN)
unnamed: D618.1 (DOUT), D619.4 (DIN)
unnamed: D621.1 (DOUT), D622.4 (DIN)
unnamed: D622.1 (DOUT), D623.4 (DIN)
unnamed: D623.1 (DOUT), D624.4 (DIN)
unnamed: D624.1 (DOUT), D625.4 (DIN)
unnamed: D625.1 (DOUT), D626.4 (DIN)
unnamed: D626.1 (DOUT), D627.4 (DIN)
unnamed: D627.1 (DOUT), D628.4 (DIN)
unnamed: D628.1 (DOUT), D629.4 (DIN)
unnamed: D631.1 (DOUT), D632.4 (DIN)
unnamed: D632.1 (DOUT), D633.4 (DIN)
unnamed: D633.1 (DOUT), D634.4 (DIN)
unnamed: D634.1 (DOUT), D635.4 (DIN)
unnamed: D635.1 (DOUT), D636.4 (DIN)
unnamed: D636.1 (DOUT), D637.4 (DIN)
unnamed: D637.1 (DOUT), D638.4 (DIN)
unnamed: D638.1 (DOUT), D639.4 (DIN)
unnamed: D641.1 (DOUT), D642.4 (DIN)
unnamed: D642.1 (DOUT), D643.4 (DIN)
unnamed: D643.1 (DOUT), D644.4 (DIN)
unnamed: D644.1 (DOUT), D645.4 (DIN)
unnamed: D645.1 (DOUT), D646.4 (DIN)
unnamed: D646.1 (DOUT), D647.4 (DIN)
unnamed: D647.1 (DOUT), D648.4 (DIN)
unnamed: D648.1 (DOUT), D649.4 (DIN)
unnamed: D619.1 (DOUT), D6110.4 (DIN)
unnamed: D6110.1 (DOUT), D6111.4 (DIN)
unnamed: D6111.1 (DOUT), D6112.4 (DIN)
unnamed: D6112.1 (DOUT), D6113.4 (DIN)
unnamed: D6113.1 (DOUT), D6114.4 (DIN)
unnamed: D6114.1 (DOUT), D6115.4 (DIN)
unnamed: D6115.1 (DOUT), D6116.4 (DIN)
unnamed: D6116.1 (DOUT), D6117.4 (DIN)
unnamed: D6117.1 (DOUT), D6118.4 (DIN)
unnamed: D6118.1 (DOUT), D6119.4 (DIN)
unnamed: D6119.1 (DOUT), D6120.4 (DIN)
unnamed: D6120.1 (DOUT), D6121.4 (DIN)
unnamed: D6121.1 (DOUT), D6122.4 (DIN)
unnamed: D6122.1 (DOUT), D6123.4 (DIN)
unnamed: D6123.1 (DOUT), D6124.4 (DIN)
unnamed: D6124.1 (DOUT), D6125.4 (DIN)
unnamed: D6125.1 (DOUT), D6126.4 (DIN)
unnamed: D6126.1 (DOUT), D6127.4 (DIN)
unnamed: D6127.1 (DOUT), D6128.4 (DIN)
unnamed: D6128.1 (DOUT), D6129.4 (DIN)
unnamed: D6129.1 (DOUT), D6130.4 (DIN)
unnamed: D621.4 (DIN), D6130.1 (DOUT)
unnamed: D629.1 (DOUT), D6210.4 (DIN)
unnamed: D6210.1 (DOUT), D6211.4 (DIN)
unnamed: D6211.1 (DOUT), D6212.4 (DIN)
unnamed: D6212.1 (DOUT), D6213.4 (DIN)
unnamed: D6213.1 (DOUT), D6214.4 (DIN)
unnamed: D6214.1 (DOUT), D6215.4 (DIN)
unnamed: D6215.1 (DOUT), D6216.4 (DIN)
unnamed: D6216.1 (DOUT), D6217.4 (DIN)
unnamed: D6217.1 (DOUT), D6218.4 (DIN)
unnamed: D6218.1 (DOUT), D6219.4 (DIN)
unnamed: D6219.1 (DOUT), D6220.4 (DIN)
unnamed: D6220.1 (DOUT), D6221.4 (DIN)
unnamed: D6221.1 (DOUT), D6222.4 (DIN)
unnamed: D6222.1 (DOUT), D6223.4 (DIN)
unnamed: D6223.1 (DOUT), D6224.4 (DIN)
unnamed: D6224.1 (DOUT), D6225.4 (DIN)
unnamed: D6225.1 (DOUT), D6226.4 (DIN)
unnamed: D6226.1 (DOUT), D6227.4 (DIN)
unnamed: D6227.1 (DOUT), D6228.4 (DIN)
unnamed: D6228.1 (DOUT), D6229.4 (DIN)
unnamed: D6229.1 (DOUT), D6230.4 (DIN)
unnamed: D631.4 (DIN), D6230.1 (DOUT)
unnamed: D639.1 (DOUT), D6310.4 (DIN)
unnamed: D6310.1 (DOUT), D6311.4 (DIN)
unnamed: D6311.1 (DOUT), D6312.4 (DIN)
unnamed: D6312.1 (DOUT), D6313.4 (DIN)
unnamed: D6313.1 (DOUT), D6314.4 (DIN)
unnamed: D6314.1 (DOUT), D6315.4 (DIN)
unnamed: D6315.1 (DOUT), D6316.4 (DIN)
unnamed: D6316.1 (DOUT), D6317.4 (DIN)
unnamed: D6317.1 (DOUT), D6318.4 (DIN)
unnamed: D6318.1 (DOUT), D6319.4 (DIN)
unnamed: D6319.1 (DOUT), D6320.4 (DIN)
unnamed: D6320.1 (DOUT), D6321.4 (DIN)
unnamed: D6321.1 (DOUT), D6322.4 (DIN)
unnamed: D6322.1 (DOUT), D6323.4 (DIN)
unnamed: D6323.1 (DOUT), D6324.4 (DIN)
unnamed: D6324.1 (DOUT), D6325.4 (DIN)
unnamed: D6325.1 (DOUT), D6326.4 (DIN)
unnamed: D6326.1 (DOUT), D6327.4 (DIN)
unnamed: D6327.1 (DOUT), D6328.4 (DIN)
unnamed: D6328.1 (DOUT), D6329.4 (DIN)
unnamed: D6329.1 (DOUT), D6330.4 (DIN)
unnamed: D641.4 (DIN), D6330.1 (DOUT)
unnamed: D649.1 (DOUT), D6410.4 (DIN)
unnamed: D6410.1 (DOUT), D6411.4 (DIN)
unnamed: D6411.1 (DOUT), D6412.4 (DIN)
unnamed: D6412.1 (DOUT), D6413.4 (DIN)
unnamed: D6413.1 (DOUT), D6414.4 (DIN)
unnamed: D6414.1 (DOUT), D6415.4 (DIN)
unnamed: D6415.1 (DOUT), D6416.4 (DIN)
unnamed: D6416.1 (DOUT), D6417.4 (DIN)
unnamed: D6417.1 (DOUT), D6418.4 (DIN)
unnamed: D6418.1 (DOUT), D6419.4 (DIN)
unnamed: D6419.1 (DOUT), D6420.4 (DIN)
unnamed: D6420.1 (DOUT), D6421.4 (DIN)
unnamed: D6421.1 (DOUT), D6422.4 (DIN)
unnamed: D6422.1 (DOUT), D6423.4 (DIN)
unnamed: D6423.1 (DOUT), D6424.4 (DIN)
unnamed: D6424.1 (DOUT), D6425.4 (DIN)
unnamed: D6425.1 (DOUT), D6426.4 (DIN)
unnamed: D6426.1 (DOUT), D6427.4 (DIN)
unnamed: D6427.1 (DOUT), D6428.4 (DIN)
unnamed: D6428.1 (DOUT), D6429.4 (DIN)
unnamed: D6429.1 (DOUT), D6430.4 (DIN)
unnamed: J2.2, J3.2, J11.2
unnamed: J2.3, J3.3, J11.3
unnamed: J2.4, J3.4, J11.4
unnamed: J2.5, J3.5, J11.5
unnamed: J2.6, J3.6, J11.6
unnamed: J2.7, J3.7, J11.7
unnamed: J2.8, J3.8, J11.8
unnamed: J2.9, J3.9, J11.9
unnamed: J2.10, J3.10, J11.10
unnamed: J2.11, J3.11, J11.11
unnamed: J2.12, J3.12, J11.12
unnamed: J2.13, J3.13, J11.13
unnamed: J2.14, J3.14, J11.14
unnamed: J2.15, J3.15, J11.15
unnamed: J2.16, J3.16, J11.16
unnamed: J2.17, J3.17, J11.17
unnamed: J2.18, J3.18, J11.18
unnamed: J2.19, J3.19, J11.19
unnamed: J2.20, J3.20, J11.20
unnamed: J2.21, J3.21, J11.21
unnamed: J2.22, J3.22, J11.22
unnamed: J2.23, J3.23, J11.23
unnamed: J2.24, J3.24, J11.24
unnamed: J2.25, J3.25, J11.25
unnamed: J2.26, J3.26, J11.26
unnamed: J2.27, J3.27, J11.27
unnamed: J2.28, J3.28, J11.28
unnamed: J2.33, J3.33, J11.33 (Pin_1)
unnamed: J2.34, J3.34, J11.34 (Pin_2)
unnamed: J2.35, J3.35, J11.35 (Pin_3)
unnamed: J2.36, J3.36, J11.36 (Pin_4)
unnamed: J2.37, J3.37, J11.37 (Pin_5)
unnamed: J2.38, J3.38, J11.38 (Pin_6)
unnamed: J2.39, J3.39, J11.39 (Pin_7)
unnamed: J2.40, J3.40, J11.40 (Pin_8)
unnamed: J2.41, J3.41, J11.41 (Pin_9)
unnamed: J2.42, J3.42, J11.42 (Pin_10)
unnamed: J2.43, J3.43, J11.43 (Pin_11)
unnamed: J2.44, J3.44, J11.44 (Pin_12)
unnamed: J2.45, J3.45, J11.45 (Pin_13)
unnamed: J2.46, J3.46, J11.46 (Pin_14)
unnamed: J2.47, J3.47, J11.47 (Pin_15)
unnamed: J2.48, J3.48, J11.48 (Pin_16)
unnamed: J2.49, J3.49, J11.49 (Pin_17)
unnamed: J2.50, J3.50, J11.50 (Pin_18)
unnamed: J2.51, J3.51, J11.51 (Pin_19)
unnamed: J2.52, J3.52, J11.52 (Pin_20)
unnamed: J2.53, J3.53, J11.53 (Pin_21)
unnamed: J2.54, J3.54, J11.54 (Pin_22)
unnamed: J2.55, J3.55, J11.55 (Pin_23)
unnamed: J2.56, J3.56, J11.56 (Pin_24)
unnamed: J2.57, J3.57, J11.57 (Pin_25)
unnamed: J2.58, J3.58, J11.58 (Pin_26)
unnamed: J2.59, J3.59, J11.59 (Pin_27)
unnamed: J2.60, J3.60, J11.60 (Pin_28)
unnamed: J5.1 (Pin_1_1), J6.1 (Pin_1_1)
unnamed: J2.32, J3.32, J11.32 (Pin_0)
unnamed: J2.29, J3.29, J11.29
unnamed: J2.31, J3.31, J11.31
Row1: J2.1, J3.1, J11.1, U11.C3 (D1), U11.C4 (D2)
Row30: J2.30, J3.30, J11.30, U12.C3 (D1), U12.C4 (D2)
SC0: U1.5 (SC0), U2.A2 (SCL)
SC1: U1.7 (SC1), U5.A2 (SCL)
SC2: U1.9 (SC2), U7.A2 (SCL)
SC3: U1.11 (SC3), U9.A2 (SCL)
SC4: U1.14 (SC4), U4.A2 (SCL)
SC5: U1.16 (SC5), U6.A2 (SCL)
SC6: U1.18 (SC6), U8.A2 (SCL)
SC7: U1.20 (SC7), U10.A2 (SCL)
SCL_0: J12.18, J13.18, M51.1 (SCL), M52.1 (SCL), M53.1 (SCL), M54.1 (SCL), M55.1 (SCL), M56.1 (SCL), M57.1 (SCL), M58.1 (SCL), M59.1 (SCL), R1.2, TP8.1 (1_1), TP14.1 (1_1), U1.22 (SCL)
SD0: U1.4 (SD0), U2.B2 (SDA)
SD1: U1.6 (SD1), U5.B2 (SDA)
SD2: U1.8 (SD2), U7.B2 (SDA)
SD3: U1.10 (SD3), U9.B2 (SDA)
SD4: U1.13 (SD4), U4.B2 (SDA)
SD5: U1.15 (SD5), U6.B2 (SDA)
SD6: U1.17 (SD6), U8.B2 (SDA)
SD7: U1.19 (SD7), U10.B2 (SDA)
SDA_0: J12.17, J13.17, M51.6 (SDA), M52.6 (SDA), M53.6 (SDA), M54.6 (SDA), M55.6 (SDA), M56.6 (SDA), M57.6 (SDA), M58.6 (SDA), M59.6 (SDA), R2.2, TP9.1 (1_1), TP15.1 (1_1), U1.23 (SDA)
SENSE_1: J2.67 (SENSE_1), J3.67 (SENSE_1), J4.1 (Pin_1_1)
SENSE_60: J1.1 (Pin_1_1), J2.66 (SENSE_60), J3.66 (SENSE_60)
TOP_NEG: J2.62 (T-), J3.62 (T-), J8.1 (Pin_1_1), J11.62 (Top_Neg), J12.3, JP1.1 (A), U11.A4 (S2)
TOP_POS: J2.61 (T+), J3.61 (T+), J7.1 (Pin_1_1), J11.61 (Top_Pos), J12.2, JP2.2 (B), U11.A3 (S1)
~RESET: J12.22, TP4.1 (1_1), U1.3 (~RESET)

Notes on the sheet:
31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56 57 58 59 60
1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 30
